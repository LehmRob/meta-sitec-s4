IMAGE_INSTALL += "kernel-module-tja1145"
IMAGE_INSTALL += "python-ftk"
