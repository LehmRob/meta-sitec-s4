IMAGE_INSTALL += "python-ftk"
IMAGE_INSTALL += "python-ftk-init"